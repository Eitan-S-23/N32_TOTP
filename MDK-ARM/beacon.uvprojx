# Keil uVision project beacon.uvprojx, settings and files
target N32WB03x (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: N32WB031KEQ6-2 Nationstech
  pack: Nationstech.N32WB03X_DFP.0.0.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x1000000,0x80000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: beacon
  AfterMake: fromelf --bin --output=.\bin\beacon.bin .\Objects\beacon.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB03X, USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\n32wb03x_std_periph_driver\inc;..\middlewares\Nationstech\ble_library\ns_ble_profile\dis\diss\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\rdts;..\middlewares\Nationstech\ble_library\ns_ble_profile\rdts\rdtss\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ahi\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\inc;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\gap;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\gatt;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\l2c;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\llc;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\lld;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\llm;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\em\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\hci\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\sch\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\aes\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\dbg\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ecc_p256\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\h4tl\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ke\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\rwip\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\rfinit\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\arch;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\src;..\middlewares\Nationstech\ble_library\ns_ble_stack\stack_common;..\middlewares\Nationstech\ble_library\ns_ble_stack\arch;..\middlewares\Nationstech\ble_library\ns_library\adv;..\middlewares\Nationstech\ble_library\ns_library\timer;..\middlewares\Nationstech\ble_library\ns_library\log;..\middlewares\Nationstech\ble_library\ns_library\sleep;..\middlewares\Nationstech\ble_library\ns_library\delay;..\middlewares\Nationstech\ble_library\ns_library\sec;..\middlewares\Nationstech\ble_library\ns_library\ble;..\user;..\user\app_profile;..\hardware\st7735;..\hardware\LCD;..\system\delay;..\SCGUI;..\SCGUI\widget;..\system;..\hardware;..\firmware\n32wb03x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x80000
  memory RVCT9: RAM 0x20004000 size 0x8000
  link misc: ..\middlewares\Nationstech\ble_library\ns_ble_stack\symdef\symbol_g15.obj
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32wb03x.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32wb03x.c
  group FWLB
    ../firmware/n32wb03x_std_periph_driver/src/: misc.c n32wb03x_adc.c n32wb03x_crc.c n32wb03x_dma.c n32wb03x_exti.c n32wb03x_gpio.c n32wb03x_rcc.c n32wb03x_rtc.c n32wb03x_tim.c n32wb03x_usart.c n32wb03x_lpuart.c n32wb03x_qflash.c n32wb03x_spi.c n32wb03x_i2c.c
  group BLE_STACK
    ../middlewares/Nationstech/ble_library/ns_ble_stack/stack_common/: rwip.c rwip_driver.c
  group BLE_PROFILE
    ../middlewares/Nationstech/ble_library/ns_ble_profile/: prf.c prf_utils.c
    ../middlewares/Nationstech/ble_library/ns_ble_profile/dis/diss/src/: diss.c diss_task.c
    ../middlewares/Nationstech/ble_library/ns_ble_profile/rdts/: rdts_common.c
    ../middlewares/Nationstech/ble_library/ns_ble_profile/rdts/rdtss/src/: rdtss.c rdtss_task.c
    ../middlewares/Nationstech/ble_library/ns_ble_stack/ip/ble/hl/src/att/: lib_att.c
  group NS_LIB
    ../middlewares/Nationstech/ble_library/ns_library/log/: ns_log_lpuart.c ns_log_usart.c
    ../middlewares/Nationstech/ble_library/ns_library/sleep/: ns_sleep.c
    ../middlewares/Nationstech/ble_library/ns_library/sec/: ns_sec.c
    ../middlewares/Nationstech/ble_library/ns_library/ble/: ns_ble.c ns_ble_task.c
  group BLE_APP
    ../user/app_profile/: app_dis.c app_totp_ble.c
    ../user/: app_ble.c
  group USER
    ../user/: main.c n32wb03x_it.c app_totp.c app_rtc.c
  group CONFIG
    ../user/: app_user_config.h
  group LCD
    ../hardware/LCD/: FONT.H LCD.c LCD.h pic.h
  group SYSTEM
    ../system/delay/: dfu_delay.c
  group SCGUI/font
    ../SCGUI/font/: lv_font_12.c lv_font_16.c lv_font_20.c lv_font_34.c
  group SCGUI/widget
    ../SCGUI/widget/: sc_gui_demo.c sc_obj_list.c sc_obj_widget.c
  group SCGUI/widget/src
    ../SCGUI/widget/src/: sc_arc.c sc_but.c sc_canvas.c sc_chart.c sc_frame.c sc_image.c sc_imagezip.c sc_keyboard.c sc_label.c sc_led.c sc_line_edit.c sc_menu.c sc_rotate.c sc_slider.c sc_switch.c sc_txtbox.c
  group SCGUI
    ../SCGUI/: sc_event_task.c sc_font.c sc_gui.c sc_key_table.c sc_lcd.c sc_menu_table.c
    ../SCGUI/APP/: app_gui.c
  group SCGUI/bmp
    ../SCGUI/bmp/: demo_test.c eda_img_32.c gif3.c jpgkm.c pointer.c sc_logo.c test_gif.c test_img.c test_zip.c watch.c
  group HAL
    ../hardware/INA226/: bsp_ina226.c
    ../hardware/AT24C02/: i2c_eeprom.c
  group XPT2046
    ../hardware/XPT2046/: xpt2046.c
